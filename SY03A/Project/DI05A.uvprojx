# Keil uVision project DI05A.uvprojx, settings and files
target V85XX (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: V85XX Generic
  pack: Vango.V85XX.1.0.2
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: di05a +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_V85XX_DRIVER
  c include: ..\Inc;..\Src;..\Drivers\CMSIS_Driver\Inc;..\Drivers\Device\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Drivers/Device
    ../Drivers/Device/Source/: v85xx_CodeRAM.c v85xx_cortex.c v85xx_LoadNVR.c
  group Drivers/CMSIS_Drivers
    ../Drivers/CMSIS_Driver/Src/: v85xx_adc.c v85xx_adc_tiny.c v85xx_ana.c v85xx_clk.c v85xx_comp.c v85xx_crypt.c v85xx_dma.c v85xx_flash.c v85xx_gpio.c v85xx_i2c.c v85xx_iso7816.c v85xx_lcd.c v85xx_misc.c v85xx_pmu.c v85xx_pwm.c v85xx_rtc.c v85xx_spi.c v85xx_tmr.c v85xx_u32k.c v85xx_uart.c v85xx_version.c v85xx_wdt.c
  group Template/MDK-ARM
    ./: startup_V85XX.s
  group APP
    ../Src/: v_stdio.c mainproc.c event.c Factory.c FM17520.C i2c.c init.c iokey.c LCD.c money.c rtc.c tariff.c u7816.c uartx.c UEnergy-rn.C verify.c v85xx_isr.c STS.c Demand.c ADRN7302Drive.c ADRN7302.c Measure.c
  group Doc
    ../Doc/: readme.txt
software components: CMSIS:CORE 4.3.0
